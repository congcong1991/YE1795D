# Keil uVision project fan.uvprojx, settings and files
target fan (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F031F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LQC2618 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,STM32F031,PC_FAN
  c include: ..\..\main;.\;..\..\key;..\..\dspcpu;..\..\display;..\..\eeprom;..\..\dspcpu\STM32F0X_FWLIB\inc;..\..\modbus;..\..\include;..\..\dspcpu\stm32f0xx
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group main
    ../../main/: main.c power.c main.h dds.c tab_sqrt_trig.c ds18B20.c
    ../../dspcpu/stm32f0xx/: startup_stm32f031.s
  group dspcpu
    ../../dspcpu/stm32f0xx/: FFT.c stm32f0xx_emu.c fft_fix.c fft_float.c stm32f0xx_it.c stm32f030.c system_stm32f0xx.c
  group key
    ../../key/: key.c menu.c
  group display
    ../../display/: display.c HT1621.c HT1623.c BA215102LCD.c
  group eeprom
    ../../eeprom/: AT24C04.c STM32F051_Flash.c
  group modbus
    ../../modbus/: ModBus.c
  group conf
    ./: conf.h conf.c
  group STM32F0XX_FWLIB
    ../../dspcpu/STM32F0X_FWLIB/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group STM32_DSP_LIB
    ../../dspcpu/STM32F10x_DSP_Lib/src/asm/arm/: cr4_fft_64_stm32.s
    ../../dspcpu/stm32f051/: fft2.s
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
